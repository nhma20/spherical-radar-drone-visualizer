Commit message: fixed another path

File: urdf/test.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link drone: geometry visual mesh filename=package://spherical-radar-drone-visualizer/mesh/drone_radar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
